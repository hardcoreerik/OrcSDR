// SPDX-License-Identifier: AGPL-3.0-or-later
#include "orcsdr_dmr_trunk/trunk.hpp"
#include <cstdlib>
#include <iostream>
#include <string>
using namespace orcsdr::dmr::trunk;
#define CHECK(x) do {if(!(x)){std::cerr<<__LINE__<<": "<<#x<<"\n";std::exit(1);}}while(0)
Bytes hex(const char* s){Bytes b{};for(unsigned i=0;i<12;i++)b[i]=uint8_t(std::stoul(std::string(s+2*i,2),nullptr,16));return b;}
Block blk(const char* s,uint8_t type,uint64_t pos,uint8_t slot=1,uint32_t e=1,uint32_t f=152157500,uint8_t cc=13){return {hex(s),e,f,uint32_t(pos/5),pos,slot,cc,type,true,true,true,false};}
void stamp(Bytes& b,uint16_t mask){auto c=crc(b)^mask;b[10]=uint8_t(c>>8);b[11]=uint8_t(c);}
int main(){
 Parser p;Grant g{};
 // Real corpus post-BPTC bytes, NOT generated by encoder. Exact expected CRC/frequencies.
 auto a=blk("3100fffc5bbbed3ea71b4bbb",4,1000);
 auto b=blk("b10d002b49e9a61304ec34c7",5,1288);
 CHECK(crc(a.bytes)==0xe111);CHECK(crc(b.bytes)==0x34c7);
 CHECK(p.feed(a,g)==Parse::pending);CHECK(p.feed(b,g)==Parse::grant);
 CHECK(g.target==6011885&&g.source==4106011&&g.slot==2&&g.absolute_lpcn==173&&g.rx_hz==152157500&&g.tx_hz==158617500&&g.cc==13);
 auto real=g;
 CHECK(p.feed(b,g)==Parse::rejected);
 for(unsigned n=0;n<96;n++){auto bad=b;bad.bytes[n/8]^=uint8_t(128>>(n%8));p.reset();CHECK(p.feed(a,g)==Parse::pending);CHECK(p.feed(bad,g)!=Parse::grant);}
 for(unsigned n=0;n<96;n++){auto bad=a;bad.bytes[n/8]^=uint8_t(128>>(n%8));p.reset();CHECK(p.feed(bad,g)!=Parse::grant);CHECK(p.feed(b,g)!=Parse::grant);}
 p.reset();CHECK(p.feed(a,g)==Parse::pending);auto wrong=b;wrong.epoch++;CHECK(p.feed(wrong,g)==Parse::rejected);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.slot=2;CHECK(p.feed(wrong,g)==Parse::rejected);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.dibit++;CHECK(p.feed(wrong,g)==Parse::rejected);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.bytes[0]|=0x40;stamp(wrong.bytes,0);CHECK(p.feed(wrong,g)==Parse::rejected);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.fec=false;CHECK(p.feed(wrong,g)!=Parse::grant);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.exact=false;CHECK(p.feed(wrong,g)!=Parse::grant);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.frequency++;CHECK(p.feed(wrong,g)==Parse::rejected);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.colour++;CHECK(p.feed(wrong,g)==Parse::rejected);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.replay=true;CHECK(p.feed(wrong,g)==Parse::rejected);
 p.reset();CHECK(p.feed(a,g)==Parse::pending);wrong=b;wrong.bytes[2]=0x10;stamp(wrong.bytes,0);CHECK(p.feed(wrong,g)==Parse::rejected);
 auto c=blk("3100fff85bbbed3ea7233d26",4,2000,1,2,152685000,8);
 auto d=blk("b1080035c9deba131554bbe6",5,2288,1,2,152685000,8);
 CHECK(p.feed(c,g)==Parse::pending);CHECK(p.feed(d,g)==Parse::grant);
 CHECK(g.rx_hz==152682500&&g.absolute_lpcn==215&&g.source==4106019&&g.slot==2&&g.cc==8);
 // Independently specified logical channel, no guessed frequency.
 auto l=blk("b10000a85bbbed3ea71b0000",3,3000);stamp(l.bytes,0xa5a5);
 CHECK(p.feed(l,g)==Parse::grant);CHECK(g.lpcn==10&&g.slot==2&&!g.absolute);
 auto logical=g;
 Follower f;CHECK(f.start(152157500,1,real.ms));CHECK(f.grant(real,real.ms));
 auto act=f.take();CHECK(act.kind==ActionKind::select_slot&&act.slot==2&&!f.audio_allowed());
 Voice v{1,152157500,real.ms,6011885,4106011,2,13,true,true,false,false};
 auto wrongv=v;wrongv.slot=1;CHECK(!f.voice(wrongv,real.ms));CHECK(!f.audio_allowed());
 CHECK(f.voice(v,real.ms));CHECK(f.audio_allowed());
 v.ended=true;CHECK(!f.voice(v,real.ms));CHECK(f.state()==State::control);CHECK(f.take().kind==ActionKind::mute);
 CHECK(!f.grant(real,real.ms)); // late-entry duplicate
 CHECK(!f.grant(logical,logical.ms));CHECK(f.seed(10,153068000,8)==MapResult::inserted);
 CHECK(f.grant(logical,logical.ms));act=f.take();CHECK(act.kind==ActionKind::tune&&act.hz==153068000);
 CHECK(!f.tune_result(act.token+1,true,153068000,2,logical.ms));CHECK(f.tune_result(act.token,true,153068000,2,logical.ms));
 CHECK(f.take().kind==ActionKind::select_slot);v={2,153068000,logical.ms,6011885,4106011,2,8,true,true,false,false};
 wrongv=v;wrongv.epoch=1;CHECK(!f.voice(wrongv,logical.ms));CHECK(f.voice(v,logical.ms));
 f.tick(logical.ms+901,true);act=f.take();CHECK(act.kind==ActionKind::tune&&act.hz==152157500&&!f.audio_allowed());
 CHECK(f.tune_result(act.token,true,152157500,3,logical.ms+902));CHECK(f.take().kind==ActionKind::mute);
 CHECK(f.seed(10,153000000,8)==MapResult::conflict);CHECK(f.map().find(10)==nullptr);
 f.stop();CHECK(f.take().kind==ActionKind::stop);CHECK(f.start(152157500,1,0,true));CHECK(!f.grant(real,real.ms));real.replay=true;CHECK(f.grant(real,real.ms));CHECK(f.take().replay);
 f.tick(real.ms+1801,true);CHECK(f.state()==State::control);CHECK(!f.audio_allowed());f.stop();
 CHECK(f.take().kind==ActionKind::stop);
 std::cout<<"PASS: real absolute grant vectors, 192 single-bit corruptions, epoch/slot/cadence/privacy gates, map conflict, same-carrier, cross-carrier, stale ack, return and replay isolation\n";
}
